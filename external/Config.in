## external/package/motion-handler/Config.in
```kconfig
config BR2_PACKAGE_MOTION_HANDLER
	bool "motion-handler"
	default y
	help
	  Includes executable for motion sensor integration.
```
